# Keil uVision project USART_DMA_Polling.uvprojx, settings and files
target USART_DMA_Polling (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN0230B3TV MindMotion
  pack: MindMotion.MM32SPIN0230_DFP.1.1.2
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: D:\project\pump_application_project\mm32\USART_DMA_Polling\post_build.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM0
  c misc: --diag_suppress=550,177,223
  c include: ..\Device\CMSIS\Core\Include;..\Device\MM32SPIN0230\HAL_Lib\inc;..\Device\MM32SPIN0230\Include;..\Core\Inc;..\Core\User
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x5c00
  memory RVCT9: RAM 0x20000000 size 0xe0
  memory RVCT10: RAM 0x200000e0 size 0xf20
  group APP
    ../Core/Src/: main.c mm32spin0230_it.c platform.c usart.c adc.c gpio.c tim.c opa.c flash_ops.c
    ../Core/User/: controller.c magic_cool.c pid.c rm_math.c rm_fft.c
  group HAL_LIB
    ../Device/MM32SPIN0230/HAL_Lib/src/: hal_adc.c hal_comp.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_hwdiv.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group STARTUP
    ../Device/MM32SPIN0230/Source/: system_mm32spin0230.c
    ../Device/MM32SPIN0230/Source/KEIL_StartAsm/: startup_mm32spin0230_keil.s
  group DOC
    ../: readme.txt
software components: CMSIS:DSP 1.8.0
